options:
  parameters:
    author: Omar
    description: Real-time jamming detection using USRP 2901R and TensorFlow Lite
    generate_options: qt_gui
    id: real_time_jamming_detection
    output_language: python
    title: Real-time Jamming Detection
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    label1: Spectrum
    vlen: fft_size
    x_axis_label: Frequency Bin
    x_start: '0'
    x_step: '1.0'
    y_axis_label: Magnitude (dB)
    y_max: '10'
    y_min: '-140'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pickle
      import os
      import sys

      # Add scripts directory to path
      sys.path.append('/home/omar/Downloads/SDRv2/scripts')

      try:
          import tensorflow as tf
          TFLITE_AVAILABLE = True
      except ImportError:
          try:
              import tflite_runtime.interpreter as tflite
              TFLITE_AVAILABLE = True
              USE_TFLITE_RUNTIME = True
          except ImportError:
              print("Error: TensorFlow Lite not available!")
              TFLITE_AVAILABLE = False

      from preprocess import RSSSIToMelSpectrogram


      class JammingDetectionBlock(gr.sync_block):
          """
          Custom GNU Radio block for real-time jamming detection.
          """
          
          def __init__(self, model_path='model/jamming_detector_lightweight.tflite', 
                       config_path='preprocessed_data/config.pkl', 
                       vector_length=1024):
              gr.sync_block.__init__(
                  self,
                  name="jamming_detection",
                  in_sig=[(np.float32, vector_length)],
                  out_sig=None
              )
              
              self.vector_length = vector_length
              self.downsample_factor = 40  # Take mean of every 40 points
              self.points_per_signal = int(vector_length / self.downsample_factor)  # ~25
              self.signal_length = 1000
              self.class_names = ['Normal', 'Constant Jammer', 'Periodic Jammer']
              
              # Buffer for accumulating signal points
              self.signal_buffer = []
              
              # Load model and config
              self.load_model(model_path)
              self.load_config(config_path)
              
              # Initialize preprocessing
              self.preprocessor = RSSSIToMelSpectrogram(
                  sampling_rate=self.config.get('sampling_rate', 1000),
                  n_fft=self.config.get('n_fft', 256),
                  hop_length=self.config.get('hop_length', 128),
                  n_mels=self.config.get('n_mels', 64),
                  sequence_length=self.config.get('sequence_length', 1000)
              )
              
              print(f"Jamming Detection Block initialized:")
              print(f"  Vector length: {self.vector_length}")
              print(f"  Downsample factor: {self.downsample_factor}")
              print(f"  Points per vector: {self.points_per_signal}")
              print(f"  Signal length: {self.signal_length}")
          
          def load_model(self, model_path):
              """Load TensorFlow Lite model."""
              try:
                  if 'USE_TFLITE_RUNTIME' in globals():
                      self.interpreter = tflite.Interpreter(model_path=model_path)
                  else:
                      self.interpreter = tf.lite.Interpreter(model_path=model_path)
                  
                  self.interpreter.allocate_tensors()
                  self.input_details = self.interpreter.get_input_details()
                  self.output_details = self.interpreter.get_output_details()
                  
                  print(f"Model loaded: {model_path}")
                  print(f"Input shape: {self.input_details[0]['shape']}")
                  print(f"Output shape: {self.output_details[0]['shape']}")
                  
              except Exception as e:
                  print(f"Error loading model: {e}")
                  raise
          
          def load_config(self, config_path):
              """Load preprocessing configuration."""
              try:
                  with open(config_path, 'rb') as f:
                      self.config = pickle.load(f)
                  print(f"Config loaded: {config_path}")
              except Exception as e:
                  print(f"Warning: Could not load config: {e}")
                  self.config = {
                      'sampling_rate': 1000,
                      'n_fft': 256,
                      'hop_length': 128,
                      'n_mels': 64,
                      'sequence_length': 1000
                  }
          
          def predict_signal(self, signal):
              """Make prediction on a complete signal."""
              try:
                  # Ensure signal is the right length
                  if len(signal) != self.signal_length:
                      if len(signal) > self.signal_length:
                          signal = signal[:self.signal_length]
                      else:
                          signal = np.pad(signal, (0, self.signal_length - len(signal)), 'constant')
                  
                  # Convert to mel spectrogram
                  mel_spec = self.preprocessor.signal_to_mel_spectrogram(signal)
                  
                  # Prepare input for model
                  input_data = mel_spec[np.newaxis, :, :, np.newaxis].astype(np.float32)
                  
                  # Run inference
                  self.interpreter.set_tensor(self.input_details[0]['index'], input_data)
                  self.interpreter.invoke()
                  
                  # Get output
                  output_data = self.interpreter.get_tensor(self.output_details[0]['index'])
                  
                  predicted_class = np.argmax(output_data[0])
                  confidence = np.max(output_data[0])
                  
                  return predicted_class, confidence
                  
              except Exception as e:
                  print(f"Error in prediction: {e}")
                  return 0, 0.0
          
          def work(self, input_items, output_items):
              """Process input vectors."""
              in0 = input_items[0]
              
              for vector in in0:
                  # Downsample by taking mean of every 40 points
                  downsampled = []
                  for i in range(0, len(vector), self.downsample_factor):
                      chunk = vector[i:i + self.downsample_factor]
                      if len(chunk) > 0:
                          downsampled.append(np.mean(chunk))
                  
                  # Add to signal buffer
                  self.signal_buffer.extend(downsampled)
                  
                  # Check if we have enough points for a complete signal
                  while len(self.signal_buffer) >= self.signal_length:
                      # Extract signal
                      signal = np.array(self.signal_buffer[:self.signal_length])
                      self.signal_buffer = self.signal_buffer[self.signal_length:]
                      
                      # Make prediction
                      predicted_class, confidence = self.predict_signal(signal)
                      
                      # Print prediction
                      class_name = self.class_names[predicted_class]
                      print(f"Prediction: {class_name} (Confidence: {confidence:.2%})")
              
              return len(input_items[0])
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
