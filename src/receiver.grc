options:
  parameters:
    author: HP
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: QPSK Receiver for USRP
  states: {}

blocks:
- name: constellation_qpsk
  id: variable
  parameters:
    value: digital.constellation_qpsk().base()
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: |
      firdes.root_raised_cosine(
          gain=1.0,
          sampling_freq=4.0,
          symbol_rate=1.0,
          alpha=0.35,
          ntaps=32*4
      )
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.01'
    max_dev: '1.5'
    osps: '1'
    sps: '4'
    taps: rrc_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 250000, 50000)
    type: ccc
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'False'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"QPSK Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: spectral_file_sink
  id: blocks_file_sink
  parameters:
    file: /home/omar/Downloads/SDR/normal_channel.txt
    type: float
    vlen: '1024'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: 915e6
    gain0: '10'
    rx_agc0: Disabled
    samp_rate: samp_rate
    stream_args: peak=0.003906
    sync: sync
    type: fc32
  states: {}

connections:
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [logpwrfft_x_0, '0', spectral_file_sink, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', logpwrfft_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
